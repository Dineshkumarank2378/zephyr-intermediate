## tests/temp_alarm/testcase.yaml
```yaml
tests:
  temp_alarm.unit:
    platform_allow:
      - native_sim
    tags:
      - unit
      - sensor
      - temp_alarm
```
